<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Electrombile_STM32F103.ewp</path>
    </project>
    <batchBuild />
</workspace>
